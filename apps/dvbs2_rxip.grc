<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>dvbs2_rxip</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>noise_power</value></param>
<param><key>value</key><value>0.2</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.005</value></param>
<param><key>stop</key><value>1.2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>symbol_rate * 2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>symbol_rate</value></param>
<param><key>value</key><value>6000000</value></param>
</block>
<block>
<key>analog_fastnoise_source_x</key>
<param><key>id</key><value>analog_fastnoise_source_x_0</value></param>
<param><key>amp</key><value>noise_power</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>seed</key><value>0</value></param>
<param><key>samples</key><value>8192</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>decoded.bin</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_pack_k_bits_bb</key>
<param><key>id</key><value>blocks_pack_k_bits_bb_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>k</key><value>8</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>dtv_dvb_bbscrambler_bb</key>
<param><key>id</key><value>dtv_dvb_bbscrambler_bb_0</value></param>
<param><key>rate5</key><value>C1_4</value></param>
<param><key>framesize2</key><value>FECFRAME_SHORT</value></param>
<param><key>standard</key><value>STANDARD_DVBS2</value></param>
</block>
<block>
<key>dtv_dvb_bch_bb</key>
<param><key>id</key><value>dtv_dvb_bch_bb_0</value></param>
<param><key>rate5</key><value>C1_4</value></param>
<param><key>framesize2</key><value>FECFRAME_SHORT</value></param>
<param><key>standard</key><value>STANDARD_DVBS2</value></param>
</block>
<block>
<key>dtv_dvb_ldpc_bb</key>
<param><key>id</key><value>dtv_dvb_ldpc_bb_0</value></param>
<param><key>rate5</key><value>C1_4</value></param>
<param><key>constellation</key><value>MOD_OTHER</value></param>
<param><key>framesize2</key><value>FECFRAME_SHORT</value></param>
<param><key>standard</key><value>STANDARD_DVBS2</value></param>
</block>
<block>
<key>dtv_dvbs2_interleaver_bb</key>
<param><key>id</key><value>dtv_dvbs2_interleaver_bb_0</value></param>
<param><key>rate3</key><value>C1_4</value></param>
<param><key>constellation</key><value>MOD_8PSK</value></param>
<param><key>framesize</key><value>FECFRAME_SHORT</value></param>
</block>
<block>
<key>dtv_dvbs2_modulator_bc</key>
<param><key>id</key><value>dtv_dvbs2_modulator_bc_0</value></param>
<param><key>interpolation</key><value>INTERPOLATION_OFF</value></param>
<param><key>rate3</key><value>C1_4</value></param>
<param><key>constellation</key><value>MOD_8PSK</value></param>
<param><key>framesize</key><value>FECFRAME_SHORT</value></param>
</block>
<block>
<key>dvbgse_bbheader_sink</key>
<param><key>id</key><value>dvbgse_bbheader_sink_0</value></param>
<param><key>rate1</key><value>C1_2</value></param>
<param><key>rate2</key><value>C1_3</value></param>
<param><key>rate3</key><value>C2_3</value></param>
<param><key>rate4</key><value>C1_5_MEDIUM</value></param>
<param><key>rate5</key><value>C1_4</value></param>
<param><key>framesize1</key><value>FECFRAME_NORMAL</value></param>
<param><key>framesize2</key><value>FECFRAME_SHORT</value></param>
<param><key>mac_address</key><value>02:00:48:55:4c:55</value></param>
<param><key>standard</key><value>STANDARD_DVBS2</value></param>
</block>
<block>
<key>dvbgse_bbheader_source</key>
<param><key>id</key><value>dvbgse_bbheader_source_0</value></param>
<param><key>rate1</key><value>C1_2</value></param>
<param><key>rate2</key><value>C1_3</value></param>
<param><key>rate3</key><value>C2_3</value></param>
<param><key>rate4</key><value>C1_5_MEDIUM</value></param>
<param><key>rate5</key><value>C1_4</value></param>
<param><key>dst_address</key><value></value></param>
<param><key>fecblocks</key><value>168</value></param>
<param><key>framesize1</key><value>FECFRAME_NORMAL</value></param>
<param><key>framesize2</key><value>FECFRAME_SHORT</value></param>
<param><key>inband</key><value>INBAND_OFF</value></param>
<param><key>mac_address</key><value>02:00:48:55:4c:55</value></param>
<param><key>ping_reply</key><value>PING_REPLY_ON</value></param>
<param><key>rolloff</key><value>RO_0_20</value></param>
<param><key>src_address</key><value></value></param>
<param><key>standard</key><value>STANDARD_DVBS2</value></param>
<param><key>tsrate</key><value>4000000</value></param>
<param><key>ipaddr_spoof</key><value>IPADDR_SPOOF_OFF</value></param>
</block>
<block>
<key>dvbs2rx_bbdescrambler_bb</key>
<param><key>id</key><value>dvbs2rx_bbdescrambler_bb_0</value></param>
<param><key>rate1</key><value>C1_2</value></param>
<param><key>rate2</key><value>C1_3</value></param>
<param><key>rate3</key><value>C2_3</value></param>
<param><key>rate4</key><value>C1_5_MEDIUM</value></param>
<param><key>rate5</key><value>C1_4</value></param>
<param><key>framesize1</key><value>FECFRAME_NORMAL</value></param>
<param><key>framesize2</key><value>FECFRAME_SHORT</value></param>
<param><key>standard</key><value>STANDARD_DVBS2</value></param>
</block>
<block>
<key>dvbs2rx_bch_decoder_bb</key>
<param><key>id</key><value>dvbs2rx_bch_decoder_bb_0</value></param>
<param><key>rate1</key><value>C1_2</value></param>
<param><key>rate2</key><value>C1_3</value></param>
<param><key>rate3</key><value>C2_3</value></param>
<param><key>rate4</key><value>C1_5_MEDIUM</value></param>
<param><key>rate5</key><value>C1_4</value></param>
<param><key>framesize1</key><value>FECFRAME_NORMAL</value></param>
<param><key>framesize2</key><value>FECFRAME_SHORT</value></param>
<param><key>outputmode</key><value>OM_MESSAGE</value></param>
<param><key>standard</key><value>STANDARD_DVBS2</value></param>
</block>
<block>
<key>dvbs2rx_ldpc_decoder_cb</key>
<param><key>id</key><value>dvbs2rx_ldpc_decoder_cb_0</value></param>
<param><key>rate1</key><value>C1_2</value></param>
<param><key>rate2</key><value>C1_3</value></param>
<param><key>rate3</key><value>C2_3</value></param>
<param><key>rate4</key><value>C1_5_MEDIUM</value></param>
<param><key>rate5</key><value>C1_4</value></param>
<param><key>constellation1</key><value>MOD_QPSK</value></param>
<param><key>constellation2</key><value>MOD_8PSK</value></param>
<param><key>framesize1</key><value>FECFRAME_NORMAL</value></param>
<param><key>framesize2</key><value>FECFRAME_SHORT</value></param>
<param><key>outputmode</key><value>OM_MESSAGE</value></param>
<param><key>infomode</key><value>INFO_OFF</value></param>
<param><key>standard</key><value>STANDARD_DVBS2</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<connection><source_block_id>analog_fastnoise_source_x_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>blocks_throttle_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pack_k_bits_bb_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_0</source_block_id><sink_block_id>dvbs2rx_ldpc_decoder_cb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvb_bbscrambler_bb_0</source_block_id><sink_block_id>dtv_dvb_bch_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvb_bch_bb_0</source_block_id><sink_block_id>dtv_dvb_ldpc_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvb_ldpc_bb_0</source_block_id><sink_block_id>dtv_dvbs2_interleaver_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvbs2_interleaver_bb_0</source_block_id><sink_block_id>dtv_dvbs2_modulator_bc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvbs2_modulator_bc_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>dvbgse_bbheader_source_0</source_block_id><sink_block_id>dtv_dvb_bbscrambler_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dvbs2rx_bbdescrambler_bb_0</source_block_id><sink_block_id>blocks_pack_k_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dvbs2rx_bbdescrambler_bb_0</source_block_id><sink_block_id>dvbgse_bbheader_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dvbs2rx_bch_decoder_bb_0</source_block_id><sink_block_id>dvbs2rx_bbdescrambler_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dvbs2rx_ldpc_decoder_cb_0</source_block_id><sink_block_id>dvbs2rx_bch_decoder_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
