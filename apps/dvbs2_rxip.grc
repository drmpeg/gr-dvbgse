options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: dvbs2_rxip
    output_language: python
  states: {}

blocks:
- name: noise_power
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.005'
    stop: '1.2'
    value: '0.2'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: symbol_rate * 2
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: '6000000'
  states: {}
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: noise_power
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: decoded.bin
    type: byte
  states: {state: disabled}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {state: disabled}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: dtv_dvb_bbscrambler_bb_0
  id: dtv_dvb_bbscrambler_bb
  parameters:
    framesize2: FECFRAME_SHORT
    rate5: C1_4
    standard: STANDARD_DVBS2
  states: {}
- name: dtv_dvb_bch_bb_0
  id: dtv_dvb_bch_bb
  parameters:
    framesize2: FECFRAME_SHORT
    rate5: C1_4
    standard: STANDARD_DVBS2
  states: {}
- name: dtv_dvb_ldpc_bb_0
  id: dtv_dvb_ldpc_bb
  parameters:
    constellation: MOD_OTHER
    framesize2: FECFRAME_SHORT
    rate5: C1_4
    standard: STANDARD_DVBS2
  states: {}
- name: dtv_dvbs2_interleaver_bb_0
  id: dtv_dvbs2_interleaver_bb
  parameters:
    constellation: MOD_8PSK
    framesize: FECFRAME_SHORT
    rate3: C1_4
  states: {}
- name: dtv_dvbs2_modulator_bc_0
  id: dtv_dvbs2_modulator_bc
  parameters:
    constellation: MOD_8PSK
    framesize: FECFRAME_SHORT
    interpolation: INTERPOLATION_OFF
    rate3: C1_4
  states: {}
- name: dvbgse_bbheader_sink_0
  id: dvbgse_bbheader_sink
  parameters:
    framesize1: FECFRAME_NORMAL
    framesize2: FECFRAME_SHORT
    mac_address: 02:00:48:55:4c:55
    rate1: C1_2
    rate2: C1_3
    rate3: C2_3
    rate4: C1_5_MEDIUM
    rate5: C1_4
    standard: STANDARD_DVBS2
  states: {}
- name: dvbgse_bbheader_source_0
  id: dvbgse_bbheader_source
  parameters:
    dst_address: ''
    fecblocks: '168'
    framesize1: FECFRAME_NORMAL
    framesize2: FECFRAME_SHORT
    inband: INBAND_OFF
    ipaddr_spoof: IPADDR_SPOOF_OFF
    mac_address: 02:00:48:55:4c:55
    ping_reply: PING_REPLY_ON
    rate1: C1_2
    rate2: C1_3
    rate3: C2_3
    rate4: C1_5_MEDIUM
    rate5: C1_4
    rolloff: RO_0_20
    src_address: ''
    standard: STANDARD_DVBS2
    tsrate: '4000000'
  states: {}
- name: dvbs2rx_bbdescrambler_bb_0
  id: dvbs2rx_bbdescrambler_bb
  parameters:
    framesize1: FECFRAME_NORMAL
    framesize2: FECFRAME_SHORT
    rate1: C1_2
    rate2: C1_3
    rate3: C2_3
    rate4: C1_5_MEDIUM
    rate5: C1_4
    standard: STANDARD_DVBS2
  states: {}
- name: dvbs2rx_bch_decoder_bb_0
  id: dvbs2rx_bch_decoder_bb
  parameters:
    framesize1: FECFRAME_NORMAL
    framesize2: FECFRAME_SHORT
    outputmode: OM_MESSAGE
    rate1: C1_2
    rate2: C1_3
    rate3: C2_3
    rate4: C1_5_MEDIUM
    rate5: C1_4
    standard: STANDARD_DVBS2
  states: {}
- name: dvbs2rx_ldpc_decoder_cb_0
  id: dvbs2rx_ldpc_decoder_cb
  parameters:
    constellation1: MOD_QPSK
    constellation2: MOD_8PSK
    framesize1: FECFRAME_NORMAL
    framesize2: FECFRAME_SHORT
    infomode: INFO_OFF
    outputmode: OM_MESSAGE
    rate1: C1_2
    rate2: C1_3
    rate3: C2_3
    rate4: C1_5_MEDIUM
    rate5: C1_4
    standard: STANDARD_DVBS2
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: int-mod
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters: {}
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: int-mod
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters: {}
  states: {}

connections:
- [analog_fastnoise_source_x_0, '0', blocks_add_xx_0, '0']
- [blocks_add_xx_0, '0', blocks_throttle_0_0, '0']
- [blocks_add_xx_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_file_sink_0, '0']
- [blocks_throttle_0_0, '0', dvbs2rx_ldpc_decoder_cb_0, '0']
- [dtv_dvb_bbscrambler_bb_0, '0', dtv_dvb_bch_bb_0, '0']
- [dtv_dvb_bch_bb_0, '0', dtv_dvb_ldpc_bb_0, '0']
- [dtv_dvb_ldpc_bb_0, '0', dtv_dvbs2_interleaver_bb_0, '0']
- [dtv_dvbs2_interleaver_bb_0, '0', virtual_sink_0, '0']
- [dtv_dvbs2_modulator_bc_0, '0', blocks_add_xx_0, '1']
- [dvbgse_bbheader_source_0, '0', dtv_dvb_bbscrambler_bb_0, '0']
- [dvbs2rx_bbdescrambler_bb_0, '0', blocks_pack_k_bits_bb_0, '0']
- [dvbs2rx_bbdescrambler_bb_0, '0', dvbgse_bbheader_sink_0, '0']
- [dvbs2rx_bch_decoder_bb_0, '0', dvbs2rx_bbdescrambler_bb_0, '0']
- [dvbs2rx_ldpc_decoder_cb_0, '0', virtual_sink_1, '0']
- [virtual_source_0, '0', dtv_dvbs2_modulator_bc_0, '0']
- [virtual_source_1, '0', dvbs2rx_bch_decoder_bb_0, '0']

metadata:
  file_format: 1
