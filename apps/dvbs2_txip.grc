<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>dvbs2_tx</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>value</key><value>1280e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rolloff</value></param>
<param><key>value</key><value>0.2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>symbol_rate * 2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>symbol_rate</value></param>
<param><key>value</key><value>6000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>taps</value></param>
<param><key>value</key><value>200</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tx_gain</value></param>
<param><key>value</key><value>40</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>89</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>vga1_gain</value></param>
<param><key>value</key><value>-8</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-35</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>-4</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>vga2_gain</value></param>
<param><key>value</key><value>10</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>25</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>dtv_dvb_bbscrambler_bb</key>
<param><key>id</key><value>dtv_dvb_bbscrambler_bb_0</value></param>
<param><key>rate5</key><value>C5_6</value></param>
<param><key>framesize2</key><value>FECFRAME_SHORT</value></param>
<param><key>standard</key><value>STANDARD_DVBS2</value></param>
</block>
<block>
<key>dtv_dvb_bch_bb</key>
<param><key>id</key><value>dtv_dvb_bch_bb_0</value></param>
<param><key>rate5</key><value>C5_6</value></param>
<param><key>framesize2</key><value>FECFRAME_SHORT</value></param>
<param><key>standard</key><value>STANDARD_DVBS2</value></param>
</block>
<block>
<key>dtv_dvb_ldpc_bb</key>
<param><key>id</key><value>dtv_dvb_ldpc_bb_0</value></param>
<param><key>rate5</key><value>C5_6</value></param>
<param><key>constellation</key><value>MOD_OTHER</value></param>
<param><key>framesize2</key><value>FECFRAME_SHORT</value></param>
<param><key>standard</key><value>STANDARD_DVBS2</value></param>
</block>
<block>
<key>dtv_dvbs2_interleaver_bb</key>
<param><key>id</key><value>dtv_dvbs2_interleaver_bb_0</value></param>
<param><key>rate3</key><value>C5_6</value></param>
<param><key>constellation</key><value>MOD_8PSK</value></param>
<param><key>framesize</key><value>FECFRAME_SHORT</value></param>
</block>
<block>
<key>dtv_dvbs2_modulator_bc</key>
<param><key>id</key><value>dtv_dvbs2_modulator_bc_0</value></param>
<param><key>interpolation</key><value>INTERPOLATION_OFF</value></param>
<param><key>rate3</key><value>C5_6</value></param>
<param><key>constellation</key><value>MOD_8PSK</value></param>
<param><key>framesize</key><value>FECFRAME_SHORT</value></param>
</block>
<block>
<key>dtv_dvbs2_physical_cc</key>
<param><key>id</key><value>dtv_dvbs2_physical_cc_0</value></param>
<param><key>rate3</key><value>C5_6</value></param>
<param><key>constellation</key><value>MOD_8PSK</value></param>
<param><key>framesize</key><value>FECFRAME_SHORT</value></param>
<param><key>goldcode</key><value>0</value></param>
<param><key>pilots</key><value>PILOTS_ON</value></param>
</block>
<block>
<key>dvbgse_bbheader_source</key>
<param><key>id</key><value>dvbgse_bbheader_source_0</value></param>
<param><key>rate1</key><value>C1_2</value></param>
<param><key>rate2</key><value>C1_3</value></param>
<param><key>rate3</key><value>C5_6</value></param>
<param><key>rate4</key><value>C1_5_MEDIUM</value></param>
<param><key>rate5</key><value>C5_6</value></param>
<param><key>dst_address</key><value>10.0.1.190</value></param>
<param><key>fecblocks</key><value>168</value></param>
<param><key>framesize1</key><value>FECFRAME_NORMAL</value></param>
<param><key>framesize2</key><value>FECFRAME_SHORT</value></param>
<param><key>inband</key><value>INBAND_OFF</value></param>
<param><key>mac_address</key><value>02:00:48:55:4c:4b</value></param>
<param><key>ping_reply</key><value>PING_REPLY_ON</value></param>
<param><key>rolloff</key><value>RO_0_20</value></param>
<param><key>src_address</key><value>44.0.0.3</value></param>
<param><key>standard</key><value>STANDARD_DVBS2</value></param>
<param><key>tsrate</key><value>4000000</value></param>
<param><key>ipaddr_spoof</key><value>IPADDR_SPOOF_OFF</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>firdes.root_raised_cosine(1.0, samp_rate, samp_rate/2, rolloff, taps)</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>osmosdr_sink</key>
<param><key>id</key><value>osmosdr_sink_0</value></param>
<param><key>bb_gain0</key><value>vga1_gain</value></param>
<param><key>bw0</key><value>6000000</value></param>
<param><key>freq0</key><value>center_freq</value></param>
<param><key>if_gain0</key><value>0</value></param>
<param><key>gain0</key><value>vga2_gain</value></param>
<param><key>args</key><value>bladerf=0,buffers=128,buflen=32768</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>average</key><value>0.2</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>center_freq</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>center_freq0</key><value>uhd.tune_request(center_freq, ((symbol_rate * (1 + rolloff)) / 2 ) + 1e5)</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>tx_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>"send_frame_size=16384,num_send_frames=128,master_clock_rate=" + str(samp_rate*2)</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<connection><source_block_id>dtv_dvb_bbscrambler_bb_0</source_block_id><sink_block_id>dtv_dvb_bch_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvb_bch_bb_0</source_block_id><sink_block_id>dtv_dvb_ldpc_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvb_ldpc_bb_0</source_block_id><sink_block_id>dtv_dvbs2_interleaver_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvbs2_interleaver_bb_0</source_block_id><sink_block_id>dtv_dvbs2_modulator_bc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvbs2_modulator_bc_0</source_block_id><sink_block_id>dtv_dvbs2_physical_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dtv_dvbs2_physical_cc_0</source_block_id><sink_block_id>fft_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dvbgse_bbheader_source_0</source_block_id><sink_block_id>dtv_dvb_bbscrambler_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0</source_block_id><sink_block_id>osmosdr_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0</source_block_id><sink_block_id>uhd_usrp_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
